KERNEL_BRANCH ?= "socfpga-${PV}-ltsi-rt"

require recipes-kernel/linux/linux-altera.inc

