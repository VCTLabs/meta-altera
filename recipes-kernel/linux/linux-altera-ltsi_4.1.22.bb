LINUX_VERSION = "4.1.22"
LINUX_VERSION_SUFFIX = "-ltsi"

SRCREV = "03934880d13f511ce0bf50c7cd77ca95b5bf90a1"

include linux-altera.inc
