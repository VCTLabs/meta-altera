LINUX_VERSION = "4.1"
LINUX_VERSION_SUFFIX = "-ltsi"

SRCREV = "11fc4600c61cc937b44f9bb15ffed6a2a2bd0eb8"

include linux-altera.inc
