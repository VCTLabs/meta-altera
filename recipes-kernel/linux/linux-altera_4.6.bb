require recipes-kernel/linux/linux-altera-latest.inc

