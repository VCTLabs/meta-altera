require recipes-kernel/linux/linux-altera-ltsi.inc

