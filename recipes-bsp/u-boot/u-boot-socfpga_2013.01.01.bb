
require ${COREBASE}/meta/recipes-bsp/u-boot/u-boot.inc
require u-boot-socfpga.inc

# This revision is the v2013.01.01 release
SRCREV = "d141e218f3195e305c1521a0d67c81b7cb504b71"

LICENSE = "GPLv2+"

PV = "2013.01.01"

